## compile-kernel/tools/patch/drivers/net/wireless/rtl88x2bu/Kconfig
```kconfig
config RTL88X2BU
    tristate "Realtek RTL88x2BU USB WiFi"
    depends on USB
    select CFG80211
    default y
```
